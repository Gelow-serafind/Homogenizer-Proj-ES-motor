# Keil uVision project Project.uvprojx, settings and files
target Proj (6220000::V6.22::ARMCLANG)
  device: HK32F0301MF4P7C HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.23
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: HK32F0301MXXC , HK32F0301MF4P7C,USE_HK32F0301MF4P7C_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\inc;..\src;..\..\Libraries\CMSIS\CM0\Core;..\..\Libraries\CMSIS\HK32F0301MxxC\Include;..\..\Libraries\CMSIS\HK32F0301MxxC\Source\ARM;..\..\Libraries\CMSIS\HK32F0301MxxC\Source;..\..\Libraries\HK32F0301MxxC_StdPeriph_Driver\inc;..\..\Libraries\HK32F0301MxxC_StdPeriph_Driver\src;..\..\Boards\Board_HK32F0301MF4P7C_EVAL\inc;..\..\Boards\Board_HK32F0301MF4P7C_EVAL\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../Libraries/CMSIS/HK32F0301MxxC/Source/: system_hk32f0301mxxc.c
    ../../Libraries/CMSIS/HK32F0301MxxC/Source/ARM/: KEIL_Startup_hk32f0301mxxc.s
  group User
    ../src/: main.c hk32f0301mxxc_it.c
  group Driver
    ../../Libraries/HK32F0301MxxC_StdPeriph_Driver/src/: hk32f0301mxxc_adc.c hk32f0301mxxc_awut.c hk32f0301mxxc_crc.c hk32f0301mxxc_dbgmcu.c hk32f0301mxxc_exti.c hk32f0301mxxc_flash.c hk32f0301mxxc_gpio.c hk32f0301mxxc_i2c.c hk32f0301mxxc_iwdg.c hk32f0301mxxc_misc.c hk32f0301mxxc_pwr.c hk32f0301mxxc_rcc.c hk32f0301mxxc_spi.c hk32f0301mxxc_syscfg.c hk32f0301mxxc_tim.c hk32f0301mxxc_uart.c hk32f0301mxxc_wwdg.c
  group Board
    ../../Boards/Board_HK32F0301MF4P7C_EVAL/src/: hk32f0301mf4p7c_eval.c hk32f0301mf4p7c_eval_i2c_ee.c hk32f0301mf4p7c_eval_spi_flash.c
